# Keil uVision project tft.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: tft
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\user;..\drive
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main.c
  group drive
    ../drive/: ili9328.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
